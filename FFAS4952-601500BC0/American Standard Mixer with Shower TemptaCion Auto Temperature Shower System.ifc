Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2021-09-29T12:16:24
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.20.24
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Sep 29 12:16:24 2021 * Host: LAPTOP-GL8UO08N * Database: C:\Users\CHATPONG\AppData\Local\Temp\{CE00012B-2DF4-4D32-9337-1DF67E10F8D1}\ifc * Database version: 5507 * Database creation date: Wed Sep 29 12:16:24 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Sep 29 12:16:24 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Sep 29 12:16:24 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcFlowTerminal: Auto Temperature Shower System FFAS4952-601500BC0, American Standard Mixer with Shower TemptaCion Auto Temperature Shower System:Auto Temperature Shower System FFAS4952-601500BC0:362983
In: Level 1
Material: Chrome, Glossy White, White
Pset_ManufacturerTypeInformation - Manufacturer: American Standard
Pset_DistributionFlowElementCommon - Reference: Auto Temperature Shower System FFAS4952-601500BC0
